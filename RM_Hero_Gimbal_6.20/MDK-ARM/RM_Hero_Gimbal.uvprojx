# Keil uVision project RM_Hero_Gimbal.uvprojx, settings and files
target RM_Hero_Gimbal (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00200000) IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM_Hero_Chassis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,STM32F427xx,ARM_MATH_CM4
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;.\Alorithm;.\APP_task;.\BSP;.\Communication;.\Motor_USE_CAN;..\MDK-ARM;.\DSP_LIB;.\DSP_LIB\include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Alorithm
    ./Alorithm/: pid.c mecanum_calc.c SystemState.c
  group APP_task
    ./APP_task/: data_pro_task.c Gimbal_task.c Gun_task.c offline_check.c test.c
  group Communication
    ./Communication/: JY61.c Remote.c minipc.c printf.c MPU6500.c protocol.c
  group Motor_USE_CAN
    ./Communication/: shiboqi.c
    ./Motor_USE_CAN/: CAN_USE_Moto.c
  group DSP_LIB
    ./DSP_LIB/: arm_cortexM4lf_math.lib
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c freertos.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ./BSP/: BSP.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Record
    ./: 修改记录.txt
software components: CMSIS:CORE 4.3.0
